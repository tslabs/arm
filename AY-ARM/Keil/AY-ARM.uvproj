# Keil uVision project AY-ARM.uvproj, settings and files
target AY-ARM (SRAM, Release) (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: AY_ARM
  c flags: Optim=4 oTime=1
  c define: VECT_TAB_SRAM
  c include: ..\Source\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group StartUp
    ../Source/StartUp/: startup_stm32f4xx.s system_stm32f4xx.c
  group Config
    ../Source/: ay-arm.h
  group Source Files
    ../Source/: main.c zx.c ay.c xm.c ay-arm.c ssg.c hw.c interrupts.c isr.s
target AY-ARM (SRAM, Debug) (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: AY_ARM
  c flags: Optim=4 oTime=1
  c define: VECT_TAB_SRAM
  c include: ..\Source\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
target AY-ARM (Flash) (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: AY_ARM
  c flags: Optim=4 oTime=1
  c include: ..\Source\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
