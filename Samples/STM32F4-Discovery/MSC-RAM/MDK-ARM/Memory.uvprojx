# Keil uVision project Memory.uvprojx, settings and files
target Release (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Memory
  c flags: Optim=4 oTime=1 OneElfS=1
  c include: c:\Tools\PROG\Keil4\ARM\RV31\INC\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Configuration
    ./: usb_config_FS.c
  group USB HW Driver
    ./: usbd_STM32F4xx_FS.c
  group Source
    ../: USBD_Demo.c usbd_user_msc.c
  group Library
    C:/Tools/PROG/Keil4/ARM/RV31/LIB/: USB_CM3.lib
  group ::Device
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40_41xxx.s system_stm32f4xx.c
target Debug (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: Memory
  c flags: Optim=1 OneElfS=1
  c include: c:\Tools\PROG\Keil4\ARM\RV31\INC\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.20.0, Device:Startup 1.3.1
